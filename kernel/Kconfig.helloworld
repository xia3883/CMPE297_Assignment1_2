## kernel/Kconfig.helloworld
```kconfig
config HELLOWORLD
  bool "print hello world chun"
  default y
  help
     This will print hello world chun
```
